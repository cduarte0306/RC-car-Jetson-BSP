FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
# SRC_URI += "file://rc-car-spi.cfg"