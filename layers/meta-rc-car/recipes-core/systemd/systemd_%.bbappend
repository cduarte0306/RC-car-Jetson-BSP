PACKAGECONFIG:append = " coredump"